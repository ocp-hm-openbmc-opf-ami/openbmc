EXTRA_OECMAKE:append:npcm8xx = " \
    -DRPMB_EMU=OFF \
    "